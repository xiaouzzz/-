# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\TIM;..\APP\KEY;..\HARDWARE\EXTI;..\SYSTEM\printf;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\IWDG;..\APP\OLED;..\HARDWARE\GAP;..\HARDWARE\SPI;..\HARDWARE\CAN;..\APP\MPU6050;..\APP\MPU6050\eMPL;..\APP\JoyStick;..\APP\NRF24L01;..\HARDWARE\FLASH;..\MALLOC;..\APP\SDCard;..\FATFS\src;..\FATFS\data;..\APP\PCA9685;..\APP\Motor;..\APP\HCSR04;..\APP\TCRT5000;..\APP\Control;..\APP\WS2812B
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIM/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/SPI/: spi.c
  group TXT
    ../TXT/: stm32f103txt.txt
  group APP
    ../APP/KEY/: key.c
    ../APP/OLED/: oled.c
    ../APP/MPU6050/: mpu6050.c mpuiic.c
    ../APP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../APP/JoyStick/: joystick.c
    ../APP/NRF24L01/: nrf24l01.c
    ../APP/Motor/: motor.c
    ../APP/HCSR04/: hcsr.c
    ../APP/Control/: control.c
    ../APP/WS2812B/: ws2812b.c
  group MALLOC
    ../MALLOC/: malloc.c
